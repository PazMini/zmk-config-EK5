## config/boards/arm/promicro_nrf52840/Kconfig.defconfig
```kconfig
if BOARD_PROMICRO_NRF52840

config CLOCK_CONTROL_NRF_K32SRC_RC
    default y

config SOC_LOW_POWER
    default y

endif
```
